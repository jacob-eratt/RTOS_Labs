# Keil uVision project Lab6.uvprojx, settings and files
target sensorboard (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR LAB6
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs Lab6.def
  group Source
    ./: startup.s Lab6.c eFile.c ff.c loader.c
    ../inc/: LaunchPad.c PLL.c ADCT0ATrigger.c ADCSWTrigger.c cr4_fft_64_stm32.s PID_stm32.s LPF.c IRDistance.c WTimer0A.c can.c WTimer1A.c Timer2A.c Timer4A.c Timer5A.c EdgeInterruptPortF.c PWMrobot.c PWMrobot.h TFLuna.c TFLuna.h FIFOsimple.c FIFOsimple.h Timer.c Timer.h CortexM.c CortexM.h
    ../RTOS_Labs_common/: OS.c ST7735.c Interpreter.c UART0int.c eDisk.c osasm.s ADC.c heap.c can0.c esp8266.c
    ../driverlib/: interrupt.c cpu.c
